# Keil uVision project ATSAMR34.uvproj, settings and files
target ATSAMR34_32 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_32 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ATSAMR34_64 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_64 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR34_128 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_128 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR34_256 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_256 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR34_32_EEPROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_32_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_32 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR34_64_EEPROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_64_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_64 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR34_128_EEPROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_128_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_128 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMR34_256_EEPROM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMR34_256_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMR34_256 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
